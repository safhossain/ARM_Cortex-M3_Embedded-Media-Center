# Keil uVision project coe718_project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: coe718_project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Application Files
    ./: main.c osObjects.h showPhotos.c game1.c game2.c game3.c usbdmain.c
  group Provided Helper Libraries
    ./: Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c KBD.c KBD.h LED.c LED.h IRQ.c
  group Custom Libraries
    ./: display.c display.h
  group USB-Related Files
    ./: adcuser.c adcuser.h audio.h type.h usb.h usbaudio.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h
  group C Image Files
    ./: lfc.c onepiece.c stardew.c tmu.c music_waves.c beethoven.c tmuNot.c scary.c
  group System Files
    ./: LPC17xx.h startup_LPC17xx.s system_LPC17xx.c system_LPC17xx.h
software components: Device:PIN 1.0.0
